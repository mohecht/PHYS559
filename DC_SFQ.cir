* Generated by Xic from cell DC_SFQ

.model jj0 jj(rtype = 0 icrit=225uA cap=60.0000fF)
.model jj1 jj(rtype = 0 icrit=250uA cap=60.0000fF)

I0 0 12 pulse(0 300uA  2ns .05ns .05ns .5ns)
BJJ1 14 5 20 jj0
BJJ2 6 15 2 jj0
BJJ3 7 17 1 jj1
LJ11 4 14 0.058pH
LJ12 19 4 0.945pH
LJ13 13 4 0.355pH
LJ21 15 8 0.05pH
LJ22 16 8 0.955pH
LJ23 8 0 0.096pH
LJ31 17 9 0.028pH
LJ32 18 9 0.961pH
LJ33 9 0 0.103pH
LQ1 12 13 1.071pH
LQ2 13 0 3.927pH
LQ3 5 6 0.913pH
LQ4 6 7 4.399pH
LQ5 7 0 1.09pH
LV1 10 5 16.8pH
LV2 11 7 15.5pH
RJ1 5 19 0.755
RJ2 6 16 0.766
RJ3 7 18 0.688
RV1 3 10 9.09
RV2 3 11 14.29
VQ 3 0 2.5mV

* Measurement points
V_after_LQ5 7 0 0V

* Transient simulation commands
.tran 0.1n 20n 0n 1p  ; Transient analysis from 0 to 20 nanoseconds
