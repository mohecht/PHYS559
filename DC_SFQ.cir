* Generated by Xic from cell DC_SFQ
I0 0 12 3 uA
JJ1 14 N5 20 jj1 area=1
JJ2 N6 15 N2 jj1 area=1
JJ3 7 17 INPUT jj1 area=1
LJ11 N4 14 0.058pH
LJ12 19 N4 0.945pH
LJ13 13 N4 0.355pH
LJ21 15 8 0.05pH
LJ22 16 8 0.955pH
LJ23 8 0 0.096pH
LJ31 17 9 0.028pH
LJ32 18 9 0.961pH
LJ33 9 0 0.103pH
LQ1 12 13 1.071pH
LQ2 13 0 3.927pH
LQ3 N5 N6 0.913pH
LQ4 N6 7 4.399pH
LQ5 7 0 1.09pH
LV1 10 N5 16.8pH
LV2 11 7 15.5pH
RJ1 N5 19 0.755
RJ2 N6 16 0.766
RJ3 7 18 0.688
RV1 N3 10 9.09
RV2 N3 11 14.29
VQ N3 0 2.5mV
.model jj1 jj(rtype=1, cct=1, icon=10m, vg=2.8m, delv=0.08m,
+ icrit=1m, r0=30, rn=1.7, cap=123.3p)

.save @I0[c]
